Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-12-20T20:18:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 20 20:18:51 2022 * Host: DESKTOP-D2DSTPK * Database: C:\Users\WINDOWS\AppData\Local\Temp\b1f4bab5-76b2-469f-8166-1cc850773c47\9fded768-539b-4379-b7f8-564cfc1f72c0\ifc * Database version: 5507 * Database creation date: Tue Dec 20 20:18:50 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 20 20:18:51 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 20 20:18:51 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_347259
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAS1M01-101500BC0_REVIT:Loven Basin mixer, FFAS1M01-101500BC0_REVIT:Loven Basin mixer:347259
In: Level 1
Material: Plastic
Pset_DistributionFlowElementCommon - Reference: Loven Basin mixer; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
